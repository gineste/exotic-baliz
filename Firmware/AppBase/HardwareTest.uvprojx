# Keil uVision project HardwareTest.uvprojx, settings and files
target HardwareTest (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HardwareTest +hex
  AfterMake: ".\Output\GenerateHex.bat"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_CUSTOM NRF52 NRF52832_XXAA NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 RTC_ON_APP_TIMER CONFIG_NFCT_PINS_AS_GPIOS
  c misc: --reduce_paths -DDEBUG -DBALIZ_V=3
  c include: Src\components\;Src\components\ant;Src\components\ble;Src\components\boards;Src\components\device;Src\components\drivers_nrf;Src\components\libraries;Src\components\serialization;Src\components\softdevice;Src\components\toolchain;Src\components\ble\ble_advertising;Src\components\ble\ble_db_discovery;Src\components\ble\ble_dtm;Src\components\ble\ble_racp;Src\components\ble\ble_radio_notification;Src\components\ble\ble_services;Src\components\ble\common;Src\components\ble\nrf_ble_gatt;Src\components\ble\nrf_ble_qwr;Src\components\ble\peer_manager;Src\components\ble\ble_services\ble_ancs_c;Src\components\ble\ble_services\ble_ans_c;Src\components\ble\ble_services\ble_bas;Src\components\ble\ble_services\ble_bas_c;Src\components\ble\ble_services\ble_bps;Src\components\ble\ble_services\ble_cscs;Src\components\ble\ble_services\ble_cts_c;Src\components\ble\ble_services\ble_dfu;Src\components\ble\ble_services\ble_dis;Src\components\ble\ble_services\ble_escs;Src\components\ble\ble_services\ble_gls;Src\components\ble\ble_services\ble_hids;Src\components\ble\ble_services\ble_hrs;Src\components\ble\ble_services\ble_hrs_c;Src\components\ble\ble_services\ble_hts;Src\components\ble\ble_services\ble_ias;Src\components\ble\ble_services\ble_ias_c;Src\components\ble\ble_services\ble_lbs;Src\components\ble\ble_services\ble_lbs_c;Src\components\ble\ble_services\ble_lls;Src\components\ble\ble_services\ble_nus;Src\components\ble\ble_services\ble_nus_c;Src\components\ble\ble_services\ble_rscs;Src\components\ble\ble_services\ble_rscs_c;Src\components\ble\ble_services\ble_tps;Src\components\ble\ble_services\experimental_ble_lns;Src\components\ble\ble_services\experimental_ble_ots;Src\components\ble\ble_services\experimental_gatts_c;Src\components\ble\ble_services\experimental_nrf_ble_cgms;Src\components\ble\ble_services\experimental_nrf_ble_ots_c;Src\components\ble\ble_services\nrf_ble_bms;Src\components\drivers_nrf\ble_flash;Src\components\drivers_nrf\clock;Src\components\drivers_nrf\common;Src\components\drivers_nrf\comp;Src\components\drivers_nrf\delay;Src\components\drivers_nrf\gpiote;Src\components\drivers_nrf\hal;Src\components\drivers_nrf\i2s;Src\components\drivers_nrf\lpcomp;Src\components\drivers_nrf\pdm;Src\components\drivers_nrf\power;Src\components\drivers_nrf\ppi;Src\components\drivers_nrf\pwm;Src\components\drivers_nrf\qdec;Src\components\drivers_nrf\qspi;Src\components\drivers_nrf\radio_config;Src\components\drivers_nrf\rng;Src\components\drivers_nrf\rtc;Src\components\drivers_nrf\saadc;Src\components\drivers_nrf\sdio;Src\components\drivers_nrf\spi_master;Src\components\drivers_nrf\spi_slave;Src\components\drivers_nrf\swi;Src\components\drivers_nrf\systick;Src\components\drivers_nrf\timer;Src\components\drivers_nrf\twis_slave;Src\components\drivers_nrf\twi_master;Src\components\drivers_nrf\uart;Src\components\drivers_nrf\usbd;Src\components\drivers_nrf\wdt;Src\components\drivers_nrf\sdio\config;Src\components\drivers_nrf\twi_master\deprecated;Src\components\drivers_nrf\twi_master\deprecated\config;Src\components\libraries\atomic;Src\components\libraries\atomic_fifo;Src\components\libraries\balloc;Src\components\libraries\block_dev;Src\components\libraries\bootloader;Src\components\libraries\bsp;Src\components\libraries\button;Src\components\libraries\crc16;Src\components\libraries\crc32;Src\components\libraries\crypto;Src\components\libraries\csense;Src\components\libraries\csense_drv;Src\components\libraries\ecc;Src\components\libraries\eddystone;Src\components\libraries\experimental_cli;Src\components\libraries\experimental_log;Src\components\libraries\experimental_memobj;Src\components\libraries\experimental_mpu;Src\components\libraries\experimental_ringbuf;Src\components\libraries\experimental_section_vars;Src\components\libraries\experimental_stack_guard;Src\components\libraries\experimental_task_manager;Src\components\libraries\fds;Src\components\libraries\fifo;Src\components\libraries\fstorage;Src\components\libraries\gfx;Src\components\libraries\gpiote;Src\components\libraries\hardfault;Src\components\libraries\hci;Src\components\libraries\led_softblink;Src\components\libraries\low_power_pwm;Src\components\libraries\mem_manager;Src\components\libraries\mutex;Src\components\libraries\pwm;Src\components\libraries\pwr_mgmt;Src\components\libraries\queue;Src\components\libraries\scheduler;Src\components\libraries\sdcard;Src\components\libraries\sensorsim;Src\components\libraries\serial;Src\components\libraries\sha256;Src\components\libraries\simple_timer;Src\components\libraries\slip;Src\components\libraries\spi_mngr;Src\components\libraries\strerror;Src\components\libraries\svc;Src\components\libraries\timer;Src\components\libraries\twi;Src\components\libraries\uart;Src\components\libraries\usbd;Src\components\libraries\util;Src\components\libraries\block_dev\empty;Src\components\libraries\block_dev\qspi;Src\components\libraries\block_dev\ram;Src\components\libraries\block_dev\sdc;Src\components\libraries\bootloader\ble_dfu;Src\components\libraries\bootloader\dfu;Src\components\libraries\bootloader\serial_dfu;Src\components\libraries\bootloader\usb_dfu;Src\components\libraries\crypto\backend;Src\components\libraries\crypto\backend\cc310_lib;Src\components\libraries\crypto\backend\micro_ecc;Src\components\libraries\crypto\backend\nrf_crypto_sw;Src\components\libraries\experimental_cli\ble_uart;Src\components\libraries\experimental_cli\cdc_acm;Src\components\libraries\experimental_cli\rtt;Src\components\libraries\experimental_cli\uart;Src\components\libraries\experimental_log\src;Src\components\libraries\hardfault\nrf51;Src\components\libraries\hardfault\nrf52;Src\components\libraries\hardfault\nrf51\handler;Src\components\libraries\hardfault\nrf52\handler;Src\components\libraries\usbd\class;Src\components\libraries\usbd\config;Src\components\libraries\usbd\class\audio;Src\components\libraries\usbd\class\cdc;Src\components\libraries\usbd\class\hid;Src\components\libraries\usbd\class\msc;Src\components\libraries\usbd\class\cdc\acm;Src\components\libraries\usbd\class\hid\generic;Src\components\libraries\usbd\class\hid\kbd;Src\components\libraries\usbd\class\hid\mouse;Src\components\serialization\application;Src\components\serialization\common;Src\components\serialization\connectivity;Src\components\serialization\application\codecs;Src\components\serialization\application\hal;Src\components\serialization\application\transport;Src\components\serialization\application\codecs\ant;Src\components\serialization\application\codecs\ble;Src\components\serialization\application\codecs\common;Src\components\serialization\application\codecs\ant\middleware;Src\components\serialization\application\codecs\ant\serializers;Src\components\serialization\application\codecs\ble\middleware;Src\components\serialization\application\codecs\ble\serializers;Src\components\serialization\common\struct_ser;Src\components\serialization\common\transport;Src\components\serialization\common\struct_ser\ant;Src\components\serialization\common\struct_ser\ble;Src\components\serialization\common\transport\ser_phy;Src\components\serialization\common\transport\ser_phy\config;Src\components\serialization\connectivity\codecs;Src\components\serialization\connectivity\hal;Src\components\serialization\connectivity\codecs\ant;Src\components\serialization\connectivity\codecs\ble;Src\components\serialization\connectivity\codecs\common;Src\components\serialization\connectivity\codecs\ant\middleware;Src\components\serialization\connectivity\codecs\ant\serializers;Src\components\serialization\connectivity\codecs\ble\middleware;Src\components\serialization\connectivity\codecs\ble\serializers;Src\components\softdevice\common;Src\components\softdevice\s132;Src\components\softdevice\s132\headers;Src\components\softdevice\s132\hex;Src\components\softdevice\s132\toolchain;Src\components\softdevice\s132\headers\nrf52;Src\components\softdevice\s132\toolchain\armgcc;Src\components\toolchain\arm;Src\components\toolchain\cmsis;Src\components\toolchain\gcc;Src\components\toolchain\iar;Src\components\toolchain\cmsis\dsp;Src\components\toolchain\cmsis\include;Src\components\toolchain\cmsis\dsp\ARM;Src\components\toolchain\cmsis\dsp\GCC;Src\config;Src;Src\Application;Src\Drivers;Src\StateMachines;Src\RTT;.\;.\RTE;.\RTE\Device;.\RTE\Device\nRF52832_xxAA;Src\external;Src\external\fprintf;Src\external\segger_rtt;Src\Libraries\ES_Libraries
  asm define: BOARD_CUSTOM NRF52 NRF52832_XXAA NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_NFCT_PINS_AS_GPIOS
  asm include: Src\components\;Src\components\ant;Src\components\ble;Src\components\boards;Src\components\device;Src\components\drivers_nrf;Src\components\libraries;Src\components\serialization;Src\components\softdevice;Src\components\toolchain;Src\components\ble\ble_advertising;Src\components\ble\ble_db_discovery;Src\components\ble\ble_dtm;Src\components\ble\ble_racp;Src\components\ble\ble_radio_notification;Src\components\ble\ble_services;Src\components\ble\common;Src\components\ble\nrf_ble_gatt;Src\components\ble\nrf_ble_qwr;Src\components\ble\peer_manager;Src\components\ble\ble_services\ble_ancs_c;Src\components\ble\ble_services\ble_ans_c;Src\components\ble\ble_services\ble_bas;Src\components\ble\ble_services\ble_bas_c;Src\components\ble\ble_services\ble_bps;Src\components\ble\ble_services\ble_cscs;Src\components\ble\ble_services\ble_cts_c;Src\components\ble\ble_services\ble_dfu;Src\components\ble\ble_services\ble_dis;Src\components\ble\ble_services\ble_escs;Src\components\ble\ble_services\ble_gls;Src\components\ble\ble_services\ble_hids;Src\components\ble\ble_services\ble_hrs;Src\components\ble\ble_services\ble_hrs_c;Src\components\ble\ble_services\ble_hts;Src\components\ble\ble_services\ble_ias;Src\components\ble\ble_services\ble_ias_c;Src\components\ble\ble_services\ble_lbs;Src\components\ble\ble_services\ble_lbs_c;Src\components\ble\ble_services\ble_lls;Src\components\ble\ble_services\ble_nus;Src\components\ble\ble_services\ble_nus_c;Src\components\ble\ble_services\ble_rscs;Src\components\ble\ble_services\ble_rscs_c;Src\components\ble\ble_services\ble_tps;Src\components\ble\ble_services\experimental_ble_lns;Src\components\ble\ble_services\experimental_ble_ots;Src\components\ble\ble_services\experimental_gatts_c;Src\components\ble\ble_services\experimental_nrf_ble_cgms;Src\components\ble\ble_services\experimental_nrf_ble_ots_c;Src\components\ble\ble_services\nrf_ble_bms;Src\components\drivers_nrf\ble_flash;Src\components\drivers_nrf\clock;Src\components\drivers_nrf\common;Src\components\drivers_nrf\comp;Src\components\drivers_nrf\delay;Src\components\drivers_nrf\gpiote;Src\components\drivers_nrf\hal;Src\components\drivers_nrf\i2s;Src\components\drivers_nrf\lpcomp;Src\components\drivers_nrf\pdm;Src\components\drivers_nrf\power;Src\components\drivers_nrf\ppi;Src\components\drivers_nrf\pwm;Src\components\drivers_nrf\qdec;Src\components\drivers_nrf\qspi;Src\components\drivers_nrf\radio_config;Src\components\drivers_nrf\rng;Src\components\drivers_nrf\rtc;Src\components\drivers_nrf\saadc;Src\components\drivers_nrf\sdio;Src\components\drivers_nrf\spi_master;Src\components\drivers_nrf\spi_slave;Src\components\drivers_nrf\swi;Src\components\drivers_nrf\systick;Src\components\drivers_nrf\timer;Src\components\drivers_nrf\twis_slave;Src\components\drivers_nrf\twi_master;Src\components\drivers_nrf\uart;Src\components\drivers_nrf\usbd;Src\components\drivers_nrf\wdt;Src\components\drivers_nrf\sdio\config;Src\components\drivers_nrf\twi_master\deprecated;Src\components\drivers_nrf\twi_master\deprecated\config;Src\components\libraries\atomic;Src\components\libraries\atomic_fifo;Src\components\libraries\balloc;Src\components\libraries\block_dev;Src\components\libraries\bootloader;Src\components\libraries\bsp;Src\components\libraries\button;Src\components\libraries\crc16;Src\components\libraries\crc32;Src\components\libraries\crypto;Src\components\libraries\csense;Src\components\libraries\csense_drv;Src\components\libraries\ecc;Src\components\libraries\eddystone;Src\components\libraries\experimental_cli;Src\components\libraries\experimental_log;Src\components\libraries\experimental_memobj;Src\components\libraries\experimental_mpu;Src\components\libraries\experimental_ringbuf;Src\components\libraries\experimental_section_vars;Src\components\libraries\experimental_stack_guard;Src\components\libraries\experimental_task_manager;Src\components\libraries\fds;Src\components\libraries\fifo;Src\components\libraries\fstorage;Src\components\libraries\gfx;Src\components\libraries\gpiote;Src\components\libraries\hardfault;Src\components\libraries\hci;Src\components\libraries\led_softblink;Src\components\libraries\low_power_pwm;Src\components\libraries\mem_manager;Src\components\libraries\mutex;Src\components\libraries\pwm;Src\components\libraries\pwr_mgmt;Src\components\libraries\queue;Src\components\libraries\scheduler;Src\components\libraries\sdcard;Src\components\libraries\sensorsim;Src\components\libraries\serial;Src\components\libraries\sha256;Src\components\libraries\simple_timer;Src\components\libraries\slip;Src\components\libraries\spi_mngr;Src\components\libraries\strerror;Src\components\libraries\svc;Src\components\libraries\timer;Src\components\libraries\twi;Src\components\libraries\uart;Src\components\libraries\usbd;Src\components\libraries\util;Src\components\libraries\block_dev\empty;Src\components\libraries\block_dev\qspi;Src\components\libraries\block_dev\ram;Src\components\libraries\block_dev\sdc;Src\components\libraries\bootloader\ble_dfu;Src\components\libraries\bootloader\dfu;Src\components\libraries\bootloader\serial_dfu;Src\components\libraries\bootloader\usb_dfu;Src\components\libraries\crypto\backend;Src\components\libraries\crypto\backend\cc310_lib;Src\components\libraries\crypto\backend\micro_ecc;Src\components\libraries\crypto\backend\nrf_crypto_sw;Src\components\libraries\experimental_cli\ble_uart;Src\components\libraries\experimental_cli\cdc_acm;Src\components\libraries\experimental_cli\rtt;Src\components\libraries\experimental_cli\uart;Src\components\libraries\experimental_log\src;Src\components\libraries\hardfault\nrf51;Src\components\libraries\hardfault\nrf52;Src\components\libraries\hardfault\nrf51\handler;Src\components\libraries\hardfault\nrf52\handler;Src\components\libraries\usbd\class;Src\components\libraries\usbd\config;Src\components\libraries\usbd\class\audio;Src\components\libraries\usbd\class\cdc;Src\components\libraries\usbd\class\hid;Src\components\libraries\usbd\class\msc;Src\components\libraries\usbd\class\cdc\acm;Src\components\libraries\usbd\class\hid\generic;Src\components\libraries\usbd\class\hid\kbd;Src\components\libraries\usbd\class\hid\mouse;Src\components\serialization\application;Src\components\serialization\common;Src\components\serialization\connectivity;Src\components\serialization\application\codecs;Src\components\serialization\application\hal;Src\components\serialization\application\transport;Src\components\serialization\application\codecs\ant;Src\components\serialization\application\codecs\ble;Src\components\serialization\application\codecs\common;Src\components\serialization\application\codecs\ant\middleware;Src\components\serialization\application\codecs\ant\serializers;Src\components\serialization\application\codecs\ble\middleware;Src\components\serialization\application\codecs\ble\serializers;Src\components\serialization\common\struct_ser;Src\components\serialization\common\transport;Src\components\serialization\common\struct_ser\ant;Src\components\serialization\common\struct_ser\ble;Src\components\serialization\common\transport\ser_phy;Src\components\serialization\common\transport\ser_phy\config;Src\components\serialization\connectivity\codecs;Src\components\serialization\connectivity\hal;Src\components\serialization\connectivity\codecs\ant;Src\components\serialization\connectivity\codecs\ble;Src\components\serialization\connectivity\codecs\common;Src\components\serialization\connectivity\codecs\ant\middleware;Src\components\serialization\connectivity\codecs\ant\serializers;Src\components\serialization\connectivity\codecs\ble\middleware;Src\components\serialization\connectivity\codecs\ble\serializers;Src\components\softdevice\common;Src\components\softdevice\s132;Src\components\softdevice\s132\headers;Src\components\softdevice\s132\hex;Src\components\softdevice\s132\toolchain;Src\components\softdevice\s132\headers\nrf52;Src\components\softdevice\s132\toolchain\armgcc;Src\components\toolchain\arm;Src\components\toolchain\cmsis;Src\components\toolchain\gcc;Src\components\toolchain\iar;Src\components\toolchain\cmsis\dsp;Src\components\toolchain\cmsis\include;Src\components\toolchain\cmsis\dsp\ARM;Src\components\toolchain\cmsis\dsp\GCC;Src\config;Src;Src\Application;Src\Drivers;Src\StateMachines;Src\RTT;.\;.\RTE;.\RTE\Device;.\RTE\Device\nRF52832_xxAA
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x55000
  memory RVCT9: RAM 0x20003000 size 0xd000
  link misc: --diag_suppress 6330
  group Application
    ./Src/: main.c GlobalDefs.h
    ./Src/Application/: SigFox.c UartManagement.c HardwareTest.c InterruptManager.c
    ./: Version.h
  group BLE
    ./Src/BLE/: BLE_Application.c
  group Config
    ./Src/config/: board.h BoardConfig.h sdk_config.h
  group Drivers
    ./Src/Drivers/ADXL362/: ADXL362.c
    ./Src/Drivers/AXSIGFOX/: AXSigFox.c
    ./Src/Drivers/BME280/: BME280.c
    ./Src/Drivers/MAX44009/: MAX44009.c
    ./Src/Drivers/VEML6075/: VEML6075.c
    ./Src/Drivers/LIS2MDL/: LIS2MDL.c
    ./Src/Drivers/LSM6DSL/: LSM6DSL.c
    ./Src/Drivers/ORG1510/: ORG1510.c
    ./Src/Drivers/ST25DV/: ST25DV.c
    ./Src/Drivers/LTC2943/: LTC2943.c
  group HAL
    ./Src/HAL/: HAL_GPIO.c HAL_I2C.c HAL_RTC.c HAL_SPI.c HAL_Timer.c HAL_UART.c
  group Libraries
    ./Src/Libraries/: AT.c ES_Queue.c Buzzer.c Tool.c SimpleLED.c NMEA.c FlashMemory.c
    ./Src/Libraries/ES_Protocol/: ES_Interfaces.c ES_Protocol.c
    ./Src/Libraries/ES_Libraries/: ExoTime.c
  group StateMachines
    ./Src/StateMachines/: MainStateMachine.c InitSM.c OperationalSM.c PowerUpSM.c ConnectedSM.c ErrorSM.c DeepSleepSM.c
  group nRF_BLE
    ./Src/components/ble/ble_advertising/: ble_advertising.c
    ./Src/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ./Src/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ./Src/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ./Src/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_DFU
    ./Src/components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
  group nRF_Drivers
    ./Src/components/drivers_nrf/clock/: nrf_drv_clock.c
    ./Src/components/drivers_nrf/common/: nrf_drv_common.c
    ./Src/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ./Src/components/drivers_nrf/hal/: nrf_nvmc.c
    ./Src/components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ./Src/components/drivers_nrf/radio_config/: radio_config.c
    ./Src/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ./Src/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ./Src/components/drivers_nrf/uart/: nrf_drv_uart.c
    ./Src/components/drivers_nrf/timer/: nrf_drv_timer.c
  group nRF_Libraries
    ./Src/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ./Src/components/libraries/timer/: app_timer.c
    ./Src/components/libraries/uart/: app_uart.c
    ./Src/components/libraries/crc16/: crc16.c
    ./Src/components/libraries/fds/: fds.c
    ./Src/components/libraries/hardfault/: hardfault_implementation.c
    ./Src/components/libraries/atomic_fifo/: nrf_atfifo.c
    ./Src/components/libraries/balloc/: nrf_balloc.c
    ./Src/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ./Src/components/libraries/experimental_memobj/: nrf_memobj.c
    ./Src/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ./Src/components/libraries/strerror/: nrf_strerror.c
    ./Src/components/libraries/twi/: app_twi.c
    ./Src/components/libraries/queue/: nrf_queue.c
    ./Src/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ./Src/components/libraries/pwm/: app_pwm.c
  group nRF_SoftDevice
    ./Src/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_SVC
    ./Src/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group RTT
    ./Src/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group external
    ./Src/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
software components: CMSIS:CORE 5.0.2, Device:Startup 8.15.2
